# Autodesk Inventor part: DM931_DN150
## iProperties
Created: 2011-01
Part Number: DM931_DN150
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
